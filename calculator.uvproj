# Keil uVision project calculator.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: calculator +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c lcd1602.c lcd1602.h matrix_key.c matrix_key.h calculator.c calculator.h ired.h ired.c
